## Kconfig
```kconfig
config ETLCPP
    bool "EtlCpp Library"
    help
        This option enables the EtlCpp Library
```
